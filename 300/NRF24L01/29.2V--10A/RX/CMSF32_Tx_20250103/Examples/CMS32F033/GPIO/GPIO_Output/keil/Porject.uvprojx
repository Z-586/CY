# Keil uVision project Porject.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMS32F033 Cmsemicon
  pack: Cmsemicon.CMS32-Series.1.1.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: Porject
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\code;..\..\..\..\..\CMSIS\Include;..\..\..\..\..\Driver\CMS32F033\inc;..\Hardware
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../code/: system_CMS32F033.c startup_CMS32F033.s
  group LIB
    ../../../../../Driver/CMS32F033/src/: gpio.c system.c retarget.c uart.c opa.c pga.c adc1.c acmp.c
  group User
    ../code/: main.c isr.c demo_gpio.c drv_RF24L01.c drv_spi.c demo_uart.c demo_opa.c demo_pga.c demo_adc1.c demo_acmp.c
    ../Hardware/: delay.c Temp.c RS485.c RS485.h
software components: CMSIS:CORE 5.4.0
